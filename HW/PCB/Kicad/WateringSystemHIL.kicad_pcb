# Repository schunsky/WateringSystemHIL

## KiCad design HW/PCB/Kicad/WateringSystemHIL.kicad_pcb

Parts:
C1, C3, C4: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6: LED_Small; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: Fuse_Small; Fuse_0805_2012Metric_Pad1.15x1.40mm_HandSolder
FB1, FB2: Ferrite_Bead_Small; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: USB_B_Micro_VBUS_Input; USB_Micro-B_Amphenol_10118194_Horizontal
J2: USB_B_Micro; GCT_USB3150-30-130-A
J3: Raspberry Pi Zero WH; PinSocket_2x20_P2.54mm_Vertical
J4: MEAS_VIN; P100-E2 Pogo Spring Test Probe Pin
J5: MEAS_I; P100-E2 Pogo Spring Test Probe Pin
J7: USART1_RX; P100-E2 Pogo Spring Test Probe Pin
J8: USART1_TX; P100-E2 Pogo Spring Test Probe Pin
J9: Motor_SW; P100-E2 Pogo Spring Test Probe Pin
J17: Boot_L; P100-E2 Pogo Spring Test Probe Pin
J18: Encoder_PINA; P100-E2 Pogo Spring Test Probe Pin
J19: Encoder_PINB; P100-E2 Pogo Spring Test Probe Pin
J20: Encoder_SW; P100-E2 Pogo Spring Test Probe Pin
R1, R2, R3, R4, R5, R9, R12, R13, R14, R17, R18, R19, R23: 10k; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R8: 10m; C_2512_6332Metric_Pad1.52x3.35mm_HandSolder
R10, R11: 100; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
TP1: TestPoint; TestPoint_Pad_D2.0mm
U1: ADS1015IDGS; TSSOP-10_3x3mm_P0.5mm
U2: LT6105CMS8-TRPBF; MSOP-8_3x3mm_P0.65mm
U3: 74HC244; SOIC-20W_7.5x12.8mm_P1.27mm
U5: AP2151W; SOT-23-5

Connections:
+3V3: C3.2, C4.2, FB2.2, J3.1 (3V3), J3.17 (3V3), R1.1, R2.1, R3.1, R4.1, R5.1, U2.2 (V+), U3.20 (VCC)
+5V: C2.2, D5.2 (A), FB1.1, J3.2 (5V), J3.4 (5V), U5.5
ADC_I2C_SCL: J3.5 (SCL/GPIO3), R2.2, U1.10 (SCL)
ADC_I2C_SDA: J3.3 (SDA/GPIO2), R1.2, U1.9 (SDA)
ADC_STAT: J3.7 (GCLK0/GPIO4), R3.2, U1.2 (ALERT/RDY)
CTL_BOOT: D4.2 (A), J3.40 (GPIO21/SCLK1), U3.11 (2A3)
CTL_POWER: D6.2 (A), J3.11 (GPIO17), U5.4
DUT_CURR: R17.2, U1.6 (AIN2), U2.5 (VOUT)
Encoder_PINA: J3.35 (GPIO19/MISO1), U3.15 (2A1)
Encoder_PINB: J3.37 (GPIO26), U3.13 (2A2)
Encoder_SW: J3.31 (GCLK2/GPIO6), U3.17 (2A0)
GND: C1.1, C2.1, C3.1, C4.1, J1.5 (GND), J1.6 (Shield), J2.5 (GND), J2.6 (Shield), J3.6 (GND), J3.9 (GND), J3.14 (GND), J3.20 (GND), J3.25 (GND), J3.30 (GND), J3.34 (GND), J3.39 (GND), R9.2, R12.2, R13.2, R14.2, R19.1, R23.2, U1.1 (ADDR), U1.3 (GND), U2.4 (V-), U3.1 (1OE), U3.2 (1A0), U3.6 (1A2), U3.8 (1A3), U3.10 (GND), U3.19 (2OE), U5.2
Motor_SW: J3.33 (PWM1/GPIO13), U3.16 (1Y1)
unnamed: C1.2, FB2.1, U1.8 (VDD)
unnamed: D1.1 (K), J3.8 (GPIO14/TXD), J7.1
unnamed: D1.2 (A), R4.2
unnamed: D2.1 (K), J3.10 (GPIO15/RXD), J8.1
unnamed: D2.2 (A), R5.2
unnamed: D3.1 (K), R9.1
unnamed: D3.2 (A), J3.16 (GPIO23)
unnamed: D4.1 (K), R23.1
unnamed: D5.1 (K), R13.1
unnamed: D6.1 (K), R14.1
unnamed: F1.1, J1.1 (VBUS)
unnamed: F1.2, FB1.2
unnamed: J2.1 (VBUS), R8.1, R11.2
unnamed: J4.1, U1.4 (AIN0)
unnamed: J5.1, U1.5 (AIN1)
unnamed: J9.1, R12.1, U3.4 (1A1)
unnamed: J17.1, U3.9 (2Y3)
unnamed: J18.1, U3.5 (2Y1)
unnamed: J19.1, U3.7 (2Y2)
unnamed: J20.1, U3.3 (2Y0)
unnamed: R10.1, U2.8 (+IN)
unnamed: R8.2, R10.2, U5.1
unnamed: R11.1, U2.1 (-IN)
unnamed: R17.1, R18.2
unnamed: R18.1, R19.2
unnamed: TP1.1, U1.7 (AIN3)

Notes on the sheet:
21.08.2021
1.00

Board: 4 copper layers, 100.0 x 100.0 mm, 46 parts (1 on the bottom side), 39 nets.

## Commit log

2021-06-23 Initial commit.
2021-07-01 PCB v0.9.0
2021-07-21 PCB v0.9.1
    Added
    - Status LEDs for Power, DUT Power, Linked
    Changed
    - Active signal state of DUT->TS LED and TS->DUT LED. Turn ON the LEDs when the signals are Low level.
    Fixed
    - An issue where the micro USB plug could not be mounted on the PCB properlly. The micro USB plub was replaced with GCT USB3150.
2021-08-21 Fixed wrong connection of Encoder_SW, Encoder_PINA and Encoder_PINB at 74HC244. Changed polarity of USART1_RX and USART1_TX status LEDs in order for the LEDs to light when data is transmitted. Remove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
2021-08-21 Added a 3D model of the PCB holder.
2021-10-10 Added a FreeCAD file which was used to export step file of watering system HIL PCB with traces and silk.
2021-10-10 Changed to use a pin socket instead of a pin header for a connector for the Raspberry Pi.
2021-10-10 Added 3D models for micro USB connectors.
